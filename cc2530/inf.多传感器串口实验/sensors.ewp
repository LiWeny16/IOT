# IAR project sensors.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: code\common; code\sensor
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCIncludePath2: D:\过程控制系统\workspace\inf.多传感器串口实验\code\common
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  group common
    code/common/: cc2530_ioctl.h gy30.c gy30.h hal_delay.c hal_delay.h hal_dht11.c hal_dht11.h iic.c iic.h uart.c uart.h
  group sensors
    code/sensor/: main.c
